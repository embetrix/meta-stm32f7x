require linux-mainline.inc

LINUX_VERSION = "6.3"
SRCBRANCH = "master"
SRCREV = "457391b0380335d5e9a5babdec90ac53928b23b4"

LIC_FILES_CHKSUM = "file://${S}/COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

