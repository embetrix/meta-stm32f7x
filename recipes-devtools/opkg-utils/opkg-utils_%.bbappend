PACKAGECONFIG:remove = " python"